inherit no-kernel-module-rrecommends
