FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

#SRC_URI += "file://dropbootargs.patch"

