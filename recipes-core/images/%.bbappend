
python _anonymous() {
    d.setVar("IMAGE_FSTYPES": "pvrexport")
}

