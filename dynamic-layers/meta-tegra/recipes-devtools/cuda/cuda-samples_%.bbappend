# vectorAdd executes a CUDA kernel; deviceQuery alone only enumerates devices.
CUDA_SAMPLES:jetson-nano-devkit = "1_Utilities/deviceQuery 0_Simple/vectorAdd"
