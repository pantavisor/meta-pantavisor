SYSROOT_DIRS:append = " ${libdir}/uuu"
