# Needed by nativesdk-jq (PACKAGECONFIG oniguruma).
BBCLASSEXTEND:append = " nativesdk"
