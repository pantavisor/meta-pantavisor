# pv-mkpvrexport (nativesdk-pv-sdk-tools) edits pvr's JSON with jq inside the SDK.
BBCLASSEXTEND:append = " nativesdk"
