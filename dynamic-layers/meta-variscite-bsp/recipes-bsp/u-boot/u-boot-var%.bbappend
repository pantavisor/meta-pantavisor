
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
	file://imx8-all-distro-bootcmd.patch \
" 

