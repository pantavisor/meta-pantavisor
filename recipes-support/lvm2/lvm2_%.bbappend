# prevent udev as default dev manager being installed as dependency
PACKAGECONFIG:remove = "udev"