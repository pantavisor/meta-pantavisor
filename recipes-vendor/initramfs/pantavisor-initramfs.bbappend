IMAGE_FSTYPES:remove = "teziimg"
