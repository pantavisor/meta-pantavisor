FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " \
    file://toradexlinux.png \
    file://marketing.tar;unpack=false \
"
