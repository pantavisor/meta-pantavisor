
DEPENDS:append = " pvr-native squashfs-tools-native "

PVR_COMPRESSION ?= "-comp xz"

INITRAMFS_IMAGE = "pantavisor-bsp"

