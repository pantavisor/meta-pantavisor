SUMMARY = "DeepSeek-R1-Distill-Qwen-1.5B GGUF packaged as a pv-llama model squashfs"

require pv-llama-model.inc

LLAMA_MODEL_NAME = "deepseek-r1"
LLAMA_MODEL_FAMILY = "deepseek-r1"
LLAMA_MODEL_PARAMS = "1.5B"
LLAMA_MODEL_VERSION = "distill-qwen-1.5b-q4_k_m"
LLAMA_MODEL_DESC = "DeepSeek-R1-Distill-Qwen-1.5B, Q4_K_M (~1.1 GB)"

LLAMA_MODEL_URL = "https://huggingface.co/unsloth/DeepSeek-R1-Distill-Qwen-1.5B-GGUF/resolve/main/DeepSeek-R1-Distill-Qwen-1.5B-Q4_K_M.gguf"
LLAMA_MODEL_SHA256 = "f3bdf9cf31dee4b57ae4e455a1cb0d01b5c2c1b50d72d3112141c195506c2840"
